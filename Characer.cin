/*@!Encoding:1250*/
variables
{
  
}

